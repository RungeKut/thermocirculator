# Keil uVision project gd32e103c8t6.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32e103c8t6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Utilities;.\Peripherals executors\Src;.\Peripherals executors\Inc
  memory RVCT4: ROM 0x8000000 size 0x1ffff
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User program
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:EVAL:GD32E10x 1.5.0, Device:GD32E10x_StdPeripherals:ADC 1.5.0, Device:GD32E10x_StdPeripherals:EXTI 1.5.0, Device:GD32E10x_StdPeripherals:FMC 1.5.0, Device:GD32E10x_StdPeripherals:GPIO 1.5.0, Device:GD32E10x_StdPeripherals:MISC 1.5.0, Device:GD32E10x_StdPeripherals:PMU 1.5.0, Device:GD32E10x_StdPeripherals:RCU 1.5.0, Device:GD32E10x_StdPeripherals:RTC 1.5.0, Device:GD32E10x_StdPeripherals:TIMER 1.5.0, Device:GD32E10x_StdPeripherals:USART 1.5.0, Device:GD32E10x_libopt 1.5.0, Device:Startup 1.5.0
